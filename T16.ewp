# IAR project T16.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: $STM_F4_LIB$\CMSIS\Include; $STM_F4_LIB$\STM32F4xx_HAL_Driver\Inc; $STM_F4_LIB$\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: T16.hex
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp
    ../../C/: main.ENU.projtempl
  group Board
    $STM_F4_LIB$/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    Board/: system_stm32f4xx.c
  group LL
    $STM_F4_LIB$/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c
